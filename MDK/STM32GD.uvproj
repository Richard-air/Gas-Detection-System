# Keil uVision project STM32GD.uvproj, settings and files
target STM32F103ZE (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32GD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10x_HD
  c include: ..\LIB\CMSIS\CM3\CoreSupport;..\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\LIB\STM32F10x_StdPeriph_Driver\src;..\LIB\STM32F10x_StdPeriph_Driver\inc;..\USER;..\LIB\STM32_EVAL;..\LIB\STM32_EVAL\STM3210E_EVAL;..\LIB\STM32_EVAL\Common;..\USER\FATes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c GPIO_config.c output_config.c ADC_DMA_config.c delay_time.c temprature_control.c sdcard.c record_data.c NVIC_config.c
  group LIB
    ../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StartUp
    ../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FAT
    ../USER/FATes/: ff.c diskio.h ff.h integer.h diskio.c ffconf.h
